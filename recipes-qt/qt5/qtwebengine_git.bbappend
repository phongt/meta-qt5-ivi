CXXFLAGS_append = " -std=c++1y -fvisibility=hidden -Wall -fPIC"
CFLAGS_append  = " -Wall -fPIC"
